# Keil uVision project Project.uvprojx, settings and files
target mdk_bootloader (6100001::V6.10.1::.\ARMCLANG)
  device: GD32F527ZM GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x110000) IROM(0x08000000,0x480000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mdk_app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe .\Objects\mdk_app.axf --bin --output .\dji_sdk_demo_rtos.bin
  c flags: Optim=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: GD32F527,SYSTEM_ARCH_RTOS=1,
  c include: ..\..\drivers\GD32F5xx_standard_peripheral\Include;..\..\middlewares\FreeRTOS-10.3.1\include;..\..\drivers\CMSIS;..\..\drivers\CMSIS\GD\GD32F5xx\Include;..\..\middlewares\FreeRTOS-10.3.1\portable\GCC\ARM_CM33_NTZ;..\..\middlewares\FreeRTOS-10.3.1\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\drivers\BSP;..\..\..\..\..\..\..\modules;..\..\..\..\..\..\..\modules\aircraft_info\include;..\..\..\..\..\..\..\modules\error\include;..\..\..\..\..\..\..\modules\camera_manager\include;..\..\..\..\..\..\..\modules\core\include;..\..\..\..\..\..\..\modules\xxx_template\include;..\..\..\..\..\..\..\modules\widget\include;..\..\..\..\..\..\..\modules\waypoint_v3\include;..\..\..\..\..\..\..\modules\waypoint_v2\include;..\..\..\..\..\..\..\modules\upgrade\include;..\..\..\..\..\..\..\modules\time_sync\include;..\..\..\..\..\..\..\modules\power_management\include;..\..\..\..\..\..\..\modules\positioning\include;..\..\..\..\..\..\..\modules\platform\include;..\..\..\..\..\..\..\modules\perception\include;..\..\..\..\..\..\..\modules\payload_xport\include;..\..\..\..\..\..\..\modules\payload_gimbal\include;..\..\..\..\..\..\..\modules\payload_camera\include;..\..\..\..\..\..\..\modules\payload_camera\payload_collaboration;..\..\..\..\..\..\..\modules\fc_subscription\include;..\..\..\..\..\..\..\modules\logger\include;..\..\..\..\..\..\..\modules\data_channel\include;..\..\..\..\..\..\..\modules\data_channel\high_speed_data_channel;..\..\..\..\..\..\..\modules\data_channel\low_speed_data_channel;..\..\..\..\..\..\..\modules\data_channel\stream_channel;..\..\..\..\..\..\..\modules\data_channel\mop_channel\mop;..\..\..\..\..\..\..\modules\flight_controller\include;..\..\..\..\..\..\..\modules\liveview\include;..\..\..\..\..\..\..\modules\gimbal_manager\include;..\..\..\..\..\..\..\modules\hms\include;..\..\..\..\..\..\..\modules\data_channel\mop_channel\mop\inc;..\..\..\common\osal;..\..\..\hal;..\..\application;..\..\drivers\GD32F5xx_usb_library\driver\Include;..\..\drivers\GD32F5xx_usb_library\device\core\Include;..\..\drivers\GD32F5xx_usb_library\device\class\cdc\Include;..\..\drivers\GD32F5xx_usb_library\ustd\class\cdc;..\..\drivers\GD32F5xx_usb_library\ustd\common;..\..\..\..\..\..\..\psdk_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x480000
  memory RVCT9: RAM 0x20000000 size 0x110000
  group bootloader
    ../../bootloader/: common.c main.c menu.c ymodem.c
    ../../../common/osal/: osal.c
  group bsp
    ../../drivers/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
    ../../drivers/BSP/: startup_gd32f5xx.s gd32f5xx_it.c button.c dji_ringbuffer.c flash_if.c uart.c upgrade_platform_opt_gd32.c led.c gd32f5xx_hw.c
  group drv/gd32f5xx_drivers
    ../../drivers/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group freertos
    ../../middlewares/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../middlewares/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../middlewares/FreeRTOS-10.3.1/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.1.2
