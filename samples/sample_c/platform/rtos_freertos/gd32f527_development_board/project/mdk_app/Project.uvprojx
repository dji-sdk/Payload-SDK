# Keil uVision project Project.uvprojx, settings and files
target mdk_app (6100001::V6.10.1::.\ARMCLANG)
  device: GD32F527ZM GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x110000) IROM(0x08000000,0x480000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mdk_app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe .\Objects\mdk_app.axf --bin --output .\PSDK_APPALIAS_V01.00.00.99.bin
  c flags: Optim=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: GD32F527,SYSTEM_ARCH_RTOS=1,USE_USB_FS, USE_BOOTLOADER
  c include: ..\..\application;..\..\drivers\GD32F5xx_standard_peripheral\Include;..\..\middlewares\FreeRTOS-10.3.1\include;..\..\drivers\CMSIS;..\..\drivers\CMSIS\GD\GD32F5xx\Include;..\..\middlewares\FreeRTOS-10.3.1\portable\GCC\ARM_CM33_NTZ;..\..\middlewares\FreeRTOS-10.3.1\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\drivers\BSP;..\..\..\..\..\module_sample;..\..\hal;..\..\drivers\GD32F5xx_usb_library\device\core\Include;..\..\drivers\GD32F5xx_usb_library\driver\Include;..\..\drivers\GD32F5xx_usb_library\device\class\cdc\Include;..\..\drivers\GD32F5xx_usb_library\ustd\common;..\..\drivers\GD32F5xx_usb_library\ustd\class\cdc;..\..\..\common\osal;..\..\..\..\..\..\..\psdk_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x480000
  memory RVCT9: RAM 0x20000000 size 0x110000
  group application
    ../../application/: main.c application.c
    ../../../common/osal/: osal.c
    ../../hal/: hal_uart.c
  group api_sample
    ../../../../../module_sample/power_management/: test_power_management.c
    ../../../../../module_sample/upgrade/: test_upgrade.c test_upgrade_common_file_transfer.c test_upgrade_platform_opt.c
    ../../../../../module_sample/utils/: util_md5.c dji_config_manager.c util_buffer.c util_file.c util_link_list.c util_misc.c util_time.c
    ../../../../../module_sample/time_sync/: test_time_sync.c
    ../../../../../module_sample/camera_manager/: test_camera_manager.c
    ../../../../../module_sample/data_transmission/: test_data_transmission.c
    ../../../../../module_sample/fc_subscription/: test_fc_subscription.c
    ../../../../../module_sample/flight_control/: test_flight_control.c
    ../../../../../module_sample/gimbal_emu/: test_payload_gimbal_emu.c
    ../../../../../module_sample/gimbal_manager/: test_gimbal_manager.c
    ../../../../../module_sample/hms/: test_hms.c
    ../../../../../module_sample/payload_collaboration/: test_payload_collaboration.c
    ../../../../../module_sample/perception/: test_perception.c
    ../../../../../module_sample/positioning/: test_positioning.c
    ../../../../../module_sample/waypoint_v2/: test_waypoint_v2.c
    ../../../../../module_sample/waypoint_v3/: test_waypoint_v3.c
    ../../../../../module_sample/widget/: file_binary_array_list_en.c test_widget.c test_widget_speaker.c
    ../../../../../module_sample/camera_emu/: test_payload_cam_emu_base.c
    ../../../../../module_sample/xport/: test_payload_xport.c
    ../../../../../module_sample/tethered_battery/: test_tethered_battery.c
  group bsp
    ../../drivers/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
    ../../drivers/BSP/: startup_gd32f5xx.s gd32f5xx_it.c button.c dji_ringbuffer.c flash_if.c pps.c uart.c upgrade_platform_opt_gd32.c led.c apply_high_power.c pwm.c can.c gd32f5xx_hw.c usb_device.c
  group drv/gd32f5xx_drivers
    ../../drivers/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group freertos
    ../../middlewares/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../middlewares/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../middlewares/FreeRTOS-10.3.1/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group usb_drivers
    ../../drivers/GD32F5xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../../drivers/GD32F5xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../../drivers/GD32F5xx_usb_library/device/class/cdc/Source/: cdc_acm_core.c
  group psdk_lib
    ../../../../../../../psdk_lib/lib/armcc_cortex-m33/: libpayload.lib
software components: CMSIS:CORE 5.1.2
